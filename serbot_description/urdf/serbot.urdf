Commit message: update serbot_teleop_key and navigation

File: serbot_description/urdf/serbot.urdf (robot description, URDF)
Before this commit: robot serbot, 5 links, 4 joints
Joints:
- joint base_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0.10 rpy=0 0 0
